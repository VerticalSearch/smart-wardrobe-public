# Keil uVision project MPU9250.uvprojx, settings and files
target MPU9250 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Radar_2.4G +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\FWLIB\src;..\SYSTEM\Timer;..\HARDWARE\control;..\HARDWARE\Key;..\HARDWARE\Oled;..\HARDWARE\USART1.DMA;..\HARDWARE\Stepper_Multi;..\HARDWARE\Action_List
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/Timer/: timer.c timer.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
  group HARDWARE
    ../HARDWARE/control/: control.c control.h
    ../HARDWARE/Oled/: oled.c oled.h oledfont.h
    ../HARDWARE/USART1.DMA/: usartdma.c usartdma.h
    ../HARDWARE/Stepper_Multi/: stepper_multi.c stepper_multi.h
    ../HARDWARE/Key/: key.c key.h
    ../HARDWARE/Action_List/: board2_action_list.c board2_action_list.h board2_action_tuning.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_spi.c
