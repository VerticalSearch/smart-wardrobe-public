# Keil uVision project MPU9250.uvprojx, settings and files
target MPU9250 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\control;..\HARDWARE\Encoder;..\HARDWARE\Filter;..\HARDWARE\GuangDian;..\HARDWARE\Key;..\HARDWARE\Laser_Common;..\HARDWARE\Motor;..\HARDWARE\Move;..\HARDWARE\Oled;..\HARDWARE\Pid;..\HARDWARE\Steer;..\HARDWARE\Stepper;..\HARDWARE\USART1.DMA;..\HARDWARE\USART2.DMA;..\HARDWARE\USART3.DMA;..\HARDWARE\USART4.DMA;..\HARDWARE\USART5.DMA;..\FWLIB\inc;..\FWLIB\src;..\SYSTEM\Timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/Timer/: timer.c timer.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
  group HARDWARE
    ../HARDWARE/control/: control.c control.h
    ../HARDWARE/Encoder/: encoder.c encoder.h
    ../HARDWARE/Filter/: filter.c filter.h
    ../HARDWARE/Key/: key.c key.h
    ../HARDWARE/Laser_Common/: laser_common.c laser_common.h
    ../HARDWARE/Motor/: motor.c motor.h
    ../HARDWARE/Oled/: oled.c oled.h oledfont.h
    ../HARDWARE/Pid/: PID.c PID.h
    ../HARDWARE/Stepper/: stepper.c Stepper.h
    ../HARDWARE/USART1.DMA/: usartdma.c usartdma.h
    ../HARDWARE/USART2.DMA/: usart2dma.c usart2dma.h
    ../HARDWARE/USART3.DMA/: usart3dma.c usart3dma.h
    ../HARDWARE/USART4.DMA/: usart4dma.c usart4dma.h
    ../HARDWARE/USART5.DMA/: usart5dma.c usart5dma.h
    ../HARDWARE/GuangDian/: guangdian.c guangdian.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_spi.c
